# Keil uVision project rak411_stm32f411_keil.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rak411_stm32f411_keil
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,USE_STM32F4XX_NUCLEO
  c misc: --C99
  c include: ..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Drivers\BSP\STM32F4xx-Nucleo;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\User\Inc;..\RAK411_lib\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core
    ../Core/: startup_stm32f411xe.s
  group Drivers/BSP/STM32F4xx-Nucleo
    ../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr_ex.c
  group User
    ../User/Src/: main.c init_wifi_module.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group RAK411_lib
    ../RAK411_lib/src/: rak_config_init.c rak_spi_apconfig.c rak_spi_auto_connect.c rak_spi_channel.c rak_spi_connect.c rak_spi_disconnect.c rak_spi_easy_config.c rak_spi_get_connect_status.c rak_spi_get_rssi.c rak_spi_get_storeconfig.c rak_spi_get_storeweb.c rak_spi_get_tcps.c rak_spi_get_version.c rak_spi_getscan.c rak_spi_interrupt.c rak_spi_interrupt_handler.c rak_spi_ipconfig_dhcp.c rak_spi_ipconfig_query.c rak_spi_open_socket.c rak_spi_ping.c rak_spi_poll_read_data.c rak_spi_power_mode.c rak_spi_psk.c rak_spi_query_dns.c rak_spi_read_data.c rak_spi_read_packet.c rak_spi_read_status.c rak_spi_reset.c rak_spi_scan.c rak_spi_send_data.c rak_spi_set_funcbitmap.c rak_spi_set_ipstatic.c rak_spi_set_listen.c rak_spi_socket_close.c rak_spi_start_web.c rak_spi_store_config.c rak_spi_store_data.c rak_spi_store_web.c rak_spi_sys_init.c rak_spi_wps.c RAK411_API.c
